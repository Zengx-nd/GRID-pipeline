# Keil uVision project TRK-KEA128_Lab1.uvprojx, settings and files
target TRK-KEA128_Lab1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: SKEAZ128xxx4 NXP
  pack: Keil.Kinetis_KEAxx_DFP.1.3.0
  cpu: IROM(0x00000000,0x00020000) IRAM(0x1FFFF000,0x00004000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: TRK-KEA128_Lab1
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1
  c include: .\Headers
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  scatter file: TRK-KEA128_Lab1.sct
  group Sources
    ./Sources/: CLK.c UART.c bl_core.c ics.c
  group Headers
    ./Headers/: CLK.h derivative.h typedefs.h UART.h ics.h
software components: CMSIS:CORE 3.20.0, Device:Startup 1.0.0
