# IAR project flash_command_run.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: flash_command_run.hex
  ILINK.IlinkOutputFile: flash_command_run.out
  ILINK.IlinkProgramEntryLabel: flash_command_run
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: flash_command_run.c
